Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2016-09-06T09:17:07
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130709_2115(x64) - Exporter 3.12.0.0 - Alternate UI 2.12.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Sep 06 09:17:07 2016* Host: NCL-TA29* Database: C:\Users\Vickersc\AppData\Local\Temp\{EEEC4EAD-DC2B-4E4F-8B9B-69213C0D959B}\ifc* Database version: 5507* Database creation date: Tue Sep 06 09:17:06 2016* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Sep 06 09:17:07 2016* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Sep 06 09:17:07 2016* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcDistributionControlElement: LightSensingHead, NBS_FlexConnectorsLtd_DylghtSnsrs_Flex7ZoneLiteLightLevelSensingHead:LightSensingHead:245505
In: Level 0
Type - PredefinedType: LIGHTSENSOR; Classification: Pr_70_70_47_21 (Uniclass2015); Material: NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_FlexConnectorsLtd_DaylightSensors_flex7ZoneLiteLightLevelSensingHead; ManufacturerName: Flex Connectors Ltd; ManufacturerURL: www.flexconnectors.co.uk; NBSCertification: http://www.nationalbimlibrary.com/cert/3vkpx5b4; NBSDescription: Daylight sensors; NBSReference: 90-65-05/415; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSTypeID: n/a; ProductInformation: www.flexconnectors.co.uk/products/zone-control/zonelite-sensor-heads; Revision: n/a; Uniclass2015Title: Daylight sensors; Uniclass2015Code: Pr_70_70_47_21; Uniclass2015Version: Products v1.3; Version: 1
Type - NBS_Data - EquipmentInterconnectivity: Wired; RemoteSetupOverride: By infrared controller; Mounting: n/a; IngressProtectionMinimum: IP20; AdjustableSensorSettings: Not required; DaylightSensitivity: Adjustable; MountingOptions: Ceiling, flush, surface; SensorRange: 7.42 x 5.66 m at 2.5 m height; OperatingTemperatureRange: -10 to 40°C
Type - Pset_SensorTypeMovementSensor - MovementSensingType: Other; TimeConstant: 0
Type - Pset_SensorTypeLightSensor - LightSensorAccuracy: 0; LightSensorRange: 1 m, 4 m; LightSensorSetPoint: 0; TimeConstant: 0
Type - IFC - IfcExportAs: IfcSensorType; IfcExportType: LIGHTSENSOR
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_70_70_47_21:Daylight sensors; CodePerformance: LVD-2006/95/EC: EMC-2004/108/EC; Color: White, red; Constituents: n/a; Description: Optional light sensing head for use alongside fzh/pir/ls to average out Lux readings over greater areas; DurationUnit: year; ExpectedLife: n/a; Features: Discreet light sensor head; Finish: n/a; Grade: n/a; Material: Nylon - PA6 UL94 V-0 rated; Manufacturer: info@flexconnectors.co.uk; ModelNumber: fzh/ls; ModelReference: ZoneLite Light Level Sensing Head; Name: DaylightSensors_flex7ZoneLiteLightLevelSensingHead_FlexConnectorsLtd; ReplacementCost: n/a; Shape: Cylindrical; Size: Ø 40 x 33.2 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
